# Keil uVision project NPlink-Mote.uvprojx, settings and files
target NPLink-Mote (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L051C8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(32000000) ELITTLE
  output: NPLink-Mote +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32L051xx,USE_STM32L0538_DISCO,USE_HAL_DRIVER,USE_DEBUG, USE_BAND_470
  c misc: --C99
  c include: ..\cpu\CMSIS;..\cpu\STM32L0xx_HAL_Driver\Inc;..\cpu;..\com\lora;..\com\serial;..\com;..\app;..\os;..\algorithm;..\cpu\STM32L0xx_HAL_Driver\Inc\Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group cpu
    ../cpu/: cpu.c bsp_rtc.c stm32l0xx_it.c stm32l0xx_hal_msp.c
    ../cpu/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c
    ../cpu/cmsis/: system_stm32l0xx.c
    ../cpu/CMSIS/: startup_stm32l051xx.s
  group lora
    ../com/lora/: aes.c LoRaMac.c sx1276.c
  group os
    ../os/: os_timer.c
  group app
    ../app/: communication.c main.c rfid.c
    ../algorithm/: data.c
